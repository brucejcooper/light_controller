# IAR project DALI_Project.ewp, settings and files
configuration G2xx2_Launchpad (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2452 MSP430G2452
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: G2xx2_LAUNCHPAD
  ICC430.newCCIncludePaths: ../Src
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2452.xcl
  XLINK.XlinkStackSize: 1
configuration F2131_TPS62260LED_338EVM (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F2131 MSP430F2131
  ICC430.CCDefines: F2131_TPS62260LED_338EVM
  group (top)
    ../Src/: command.c command.h dali.c dali.h dali_demo_hw.h Dali_HPA338.c dali_infod_default.c special_command.c special_command.h
